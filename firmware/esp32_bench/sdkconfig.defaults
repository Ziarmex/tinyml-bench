## firmware/esp32_bench/sdkconfig.defaults
```kconfig
# SPDX-License-Identifier: MIT
CONFIG_ESP_DEFAULT_CPU_FREQ_MHZ_240=y
CONFIG_LOG_DEFAULT_LEVEL_INFO=y
CONFIG_ESP_CONSOLE_UART_DEFAULT=y
```
